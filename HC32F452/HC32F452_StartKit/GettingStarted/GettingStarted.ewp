# IAR project GettingStarted.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: HC32F452xE XHSC HC32F452xE
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Core\Include; $TOOLKIT_DIR$/inc/XHSC; common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.hex
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group cmsis
    ./: startup_hc32f452.s
    common/: system_hc32f452.c
  group source
    source/: main.c
